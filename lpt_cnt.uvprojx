# Keil uVision project lpt_cnt.uvprojx, settings and files
target lpt_cnt_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L073KATA HDSC
  pack: HDSC.HC32L07X.1.1.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpt_cnt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c misc: --locale=english
  c include: ..\HC32\HC32L07x_DDL_Rev1.2.0\mcu\common;..\source;..\HC32\HC32L07x_DDL_Rev1.2.0\driver\inc;..\HC32\HC32L07x_DDL_Rev1.2.0\midware\inc;..\GB_Protocal;.\.cmsis\include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l07x.s
    ../HC32/HC32L07x_DDL_Rev1.2.0/mcu/common/: system_hc32l07x.c interrupts_hc32l07x.c
  group source
    ../source/: main.c data_process.c hc32_it.c hc32_usart.c ds18b20.c w25q128.c app_CSK4002.c app_IDM40.c app_XL2409.c app_drive.c app_led.c
  group GB_Protocal
    ../GB_Protocal/: GB_WData.c GB_WDataCRC.c GB_WDataFunc.c GB_WDataPortEvent.c GB_WDataPortSerial.c GB_WDataPortTimer.c GB_WDataTPS.c GB_WDataUtils.c port.c
  group driver
    ../HC32/HC32L07x_DDL_Rev1.2.0/driver/src/: adt.c ddl.c flash.c gpio.c lpm.c lptim.c sysctrl.c uart.c rtc.c adc.c bgr.c spi.c lpuart.c reset.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
